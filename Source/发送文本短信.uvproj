# Keil uVision project 发送文本短信.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 发送文本短信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c main.c uart.c SIMxxx.c timer0.c lcd.c
